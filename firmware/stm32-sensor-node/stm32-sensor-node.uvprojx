# Keil uVision project stm32-sensor-node.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32-sensor-node
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM4F;.\FreeRTOS\config;.\Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./Src/: freertos_callbacks.c main.c clock.c uart.c i2c.c bmp280.c format.c sensor_task.c
  group FreeRTOS Core
    ./FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c
  group FreeRTOS Portable
    ./FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS Config
    ./FreeRTOS/config/: FreeRTOSConfig.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
